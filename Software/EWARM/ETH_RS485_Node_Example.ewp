# IAR project ETH_RS485_Node_Example.ewp, settings and files
configuration ETH_RS485_Node_Example (ARM, debug)
  General.OGChipSelectEditMenu: STM32F412VE ST STM32F412VE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F412Vx
  ICCARM.IExtraOptions: --diag_suppress Pe1644; --diag_suppress Pa181; --diag_suppress Pe177; --diag_suppress Pe188
  ICCARM.CCIncludePath2: ../Inc; ../Drivers/STM32F4xx_HAL_Driver/Inc; ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy; ../Middlewares/Third_Party/FreeRTOS/Source/include; ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS; ../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM4F; ../Drivers/CMSIS/Device/ST/STM32F4xx/Include; ../Drivers/CMSIS/Include; ..\Middlewares\Third_Party\FreeRTOS-Plus-TCP\include; ..\Middlewares\Third_Party\FreeRTOS-Plus-TCP\portable\Compiler\IAR; ..\Middlewares\Third_Party\FreeRTOS\Source; ..\Middlewares\STM32 Cryptographic library package V2.0.6\Libraries\STM32_Cryptographic_Library\inc\HASH\SHA256; ..\Middlewares\STM32 Cryptographic library package V2.0.6\Libraries\STM32_Cryptographic_Library\inc; ..\Middlewares\Third_Party\FreeRTOS-IoT-Libraries\c_sdk\standard\mqtt\include; ..\Middlewares\Third_Party\FreeRTOS-IoT-Libraries\c_sdk\standard\common\include; ..\Inc\configurations; ..\Middlewares\Third_Party\FreeRTOS-IoT-Libraries\abstractions\platform\freertos\include; ..\Middlewares\Third_Party\FreeRTOS-IoT-Libraries\c_sdk; ..\Middlewares\Third_Party\FreeRTOS-IoT-Libraries\c_sdk\platform; ..\Middlewares\Third_Party\FreeRTOS-IoT-Libraries\abstractions\platform\freertos\private\taskpool; ..\Middlewares\Third_Party\mbedtls\include; ..\Middlewares\Third_Party\FreeRTOS-IoT-Libraries\c_sdk\standard\common\include; ..\Middlewares\Third_Party\printf-master
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\\Inc
  OBJCOPY.OOCOutputFile: ETH_RS485_Node_Example.bin
  ILINK.IlinkOutputFile: ETH_RS485_Node_Example.out
  ILINK.IlinkIcfFile: stm32f412vx_flash.icf
  ILINK.IlinkExtraOptions: --redirect malloc=pvPortMalloc; --redirect free=vPortFree
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32f412vx.s
  group Application/User
    ../Src/: bus_uart.c bus_uart_tcp.c freertos.c http.c main.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c stm32f4xx_it.c
  group Application/User/inc
    ../Inc/: bus_uart.h bus_uart_tcp.h http.h main.h stm32f4xx_it.h
  group Application/User/inc/configurations
    ../Inc/configurations/: demo_config.h FreeRTOSConfig.h FreeRTOSIPConfig.h iot_config.h mqtt_demo_profile.h stm32f4xx_hal_conf.h
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_adc.c stm32f4xx_hal_cortex.c stm32f4xx_hal_crc.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_exti.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM4F/: port.c portasm.s
  group Middlewares/FreeRTOS/MQTT/inc
    ../Middlewares/Third_Party/FreeRTOS-IoT-Libraries/c_sdk/standard/mqtt/include/: iot_mqtt.h iot_mqtt_lightweight.h iot_mqtt_protocol.h
  group Middlewares/FreeRTOS/MQTT/src
    ../Middlewares/Third_Party/FreeRTOS-IoT-Libraries/c_sdk/standard/mqtt/src/: iot_mqtt_api.c iot_mqtt_helper.c iot_mqtt_lightweight_api.c iot_mqtt_network.c iot_mqtt_operation.c iot_mqtt_serialize.c iot_mqtt_static_memory.c iot_mqtt_subscription.c iot_mqtt_validate.c
  group Middlewares/FreeRTOS/Platform/inc
    ../Middlewares/Third_Party/FreeRTOS-IoT-Libraries/c_sdk/platform/: iot_clock.h iot_metrics.h iot_network.h iot_threads.h
  group Middlewares/FreeRTOS/Platform/src
    ../Middlewares/Third_Party/FreeRTOS-IoT-Libraries/abstractions/platform/freertos/: iot_clock_freertos.c iot_network_freertos.c iot_threads_freertos.c
    ../Middlewares/Third_Party/FreeRTOS-IoT-Libraries/abstractions/platform/freertos/private/taskpool/: taskpool_freertos.c
  group Middlewares/FreeRTOS/TCP_IP/inc
    ../Middlewares/Third_Party/FreeRTOS-Plus-TCP/include/: FreeRTOS_ARP.h FreeRTOS_DHCP.h FreeRTOS_DNS.h FreeRTOS_errno_TCP.h FreeRTOS_IP.h FreeRTOS_IP_Private.h FreeRTOS_Sockets.h FreeRTOS_Stream_Buffer.h FreeRTOS_TCP_IP.h FreeRTOS_TCP_WIN.h FreeRTOS_UDP_IP.h FreeRTOSIPConfigDefaults.h IPTraceMacroDefaults.h NetworkBufferManagement.h NetworkInterface.h phyHandling.h
  group Middlewares/FreeRTOS/TCP_IP/src
    ../Middlewares/Third_Party/FreeRTOS-Plus-TCP/portable/BufferManagement/: BufferAllocation_2.c
    ../Middlewares/Third_Party/FreeRTOS-Plus-TCP/: FreeRTOS_ARP.c FreeRTOS_DHCP.c FreeRTOS_DNS.c FreeRTOS_IP.c FreeRTOS_Sockets.c FreeRTOS_Stream_Buffer.c FreeRTOS_TCP_IP.c FreeRTOS_TCP_WIN.c FreeRTOS_UDP_IP.c
    ../Middlewares/Third_Party/FreeRTOS-Plus-TCP/portable/NetworkInterface/STM32L431_UART/: NetworkInterface.c
  group Middlewares/Master_printf/inc
    ../Middlewares/Third_Party/printf-master/: printf.h
  group Middlewares/Master_printf/src
    ../Middlewares/Third_Party/printf-master/: printf.c
  group Middlewares/SHA-256
    ../Middlewares/STM32 Cryptographic library package V2.0.6/Libraries/STM32_Cryptographic_Library/binary/EWARM/: M4_CryptoFW_2_0_6.a
